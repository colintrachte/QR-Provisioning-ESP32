#include "ui_icons.h"
/* ────────────────────────────────────────────────────────────────────────── */
/* 8×8 Runtime Status Icons                                                  */
/* ────────────────────────────────────────────────────────────────────────── */

/* * Horizontal Battery Icon
 * Logic: Rows 2-5 form the 8x4 body.
 * The terminal/nub is at the right-most column (0x01).
 */

/* Horizontal Battery (Body is 6x4, Nub is 1x2) */
const uint8_t ICON_BAT_0[8]   = { 0x00, 0x00, 0x7E, 0x42, 0x43, 0x42, 0x7E, 0x00 };
const uint8_t ICON_BAT_25[8]  = { 0x00, 0x00, 0x7E, 0x52, 0x53, 0x52, 0x7E, 0x00 };
const uint8_t ICON_BAT_50[8]  = { 0x00, 0x00, 0x7E, 0x5A, 0x5B, 0x5A, 0x7E, 0x00 };
const uint8_t ICON_BAT_75[8]  = { 0x00, 0x00, 0x7E, 0x7A, 0x7B, 0x7A, 0x7E, 0x00 };
const uint8_t ICON_BAT_100[8] = { 0x00, 0x00, 0x7E, 0x7E, 0x7F, 0x7E, 0x7E, 0x00 };

/* Dynamic Staircase WiFi: 0 to 4 bars based on RSSI */
const uint8_t ICON_WIFI_0[8] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03 }; // Just the floor
const uint8_t ICON_WIFI_1[8] = { 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03 }; // 1 bar
const uint8_t ICON_WIFI_2[8] = { 0x00, 0x00, 0x0C, 0x0C, 0x0F, 0x0F, 0x0F, 0x0F }; // 2 bars
const uint8_t ICON_WIFI_3[8] = { 0x30, 0x30, 0x3C, 0x3C, 0x3F, 0x3F, 0x3F, 0x3F }; // 3 bars

const uint8_t ICON_ARMED[8] = {
    0x18,0x3C,0x7E,0x7E,0x7E,0x3C,0x18,0x00
};

const uint8_t ICON_DISARMED[8] = {
    0x3C,0x42,0x81,0x81,0x81,0x42,0x3C,0x00
};

const uint8_t ICON_TEMP_WARN[8] = {
    0x18,0x3C,0x3C,0x7E,0x7E,0x3C,0x18,0x18
};

const uint8_t ICON_MOTOR_L[8] = {
    0x00,0x03,0x0F,0x3C,0x3C,0x0F,0x03,0x00
};

const uint8_t ICON_MOTOR_R[8] = {
    0x00,0xC0,0xF0,0x3C,0x3C,0xF0,0xC0,0x00
};

const uint8_t* ui_icon_get_battery(uint8_t pct) {
    if (pct >= 90) return ICON_BAT_100;
    if (pct >= 70) return ICON_BAT_75;
    if (pct >= 45) return ICON_BAT_50;
    if (pct >= 20) return ICON_BAT_25;
    return ICON_BAT_0;
}

const uint8_t* ui_icon_get_wifi(int8_t rssi) {
    if (rssi >= -55) return ICON_WIFI_3;
    if (rssi >= -70) return ICON_WIFI_2;
    if (rssi >= -82) return ICON_WIFI_1;
    return ICON_WIFI_0;
}
